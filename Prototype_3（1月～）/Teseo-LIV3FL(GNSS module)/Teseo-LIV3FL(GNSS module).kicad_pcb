# Repository TORICA-Org/26th_PCB_AirData

File README.md:

# 26th_PCB_AirData
メイン兼エアデータセンサー部（今後，エアデータと言います）のリポジトリです．
## 基板作成時の注意点
PCBエディターで基板上の配線をするときに気をつけてほしい点・できるだけ避けるべき点が書いてあります．これが全てではないのですが，最低限これらは守ってほしいです🙏( ｀・∀・´)ﾉﾖﾛｼｸ  
また，基板作成のコツを最後に載せてあります  
### KiCadの初期設定
これから表面実装化に向けた，小さく密度の高い基板を作ろうとするとKiCadの初期設定状態では不便が生じます．それは例えば配線のクリアランス（配線同士の最低間隔）やビア半径の初期設定値が大きすぎるためです．  
以下の画像下部のGNDビアはその上のコンデンサと同じぐらいの大きさになっていて，もはや邪魔です．  
  
そこで，以下の画像左上「ビア：ネットクラスのサイズを使用」からより小さい半径を指定できるのですが，[JLCPCBの製造能力](https://jlcpcb.com/jp/capabilities/pcb-capabilities)には限界があるわけでその限界を突破しないギリギリで設計する必要があります．その限界を突破していないか確認してくれる機能を活用するためにKiCad初期設定を変更します．この設定はプロジェクトを新たに作成する際に毎回設定する必要があります．  
  
ただし注意点の一つとして，**ビアのサイズを小さくすると急激に価格が跳ね上がる**ということがあります．これはJLCPCBの製造能力ページを見るだけではわからず，発注画面まで行って分かることなのですがビア外径0.4mm，内径0.3mmを下回るサイズのビアを打つとその個数に関わらず＋￥7200~9700されます．絶望ですね．はい...気をつけましょう．私はそんなことも知らず発注直前まで行って気付き，1430個のビアを打ち直すことになりました(┬┬﹏┬┬)
  
1. ファイル ＞ 基板の設定

2. デザインルール ＞ 制約

3. 以下のようにパラメータを変更  

---  

### USBの配線について
USBは差動伝送で通信しています．そのため，2本の配線のどちらかにだけノイズが乗ることや配線長に差があること，配線が長すぎることは避けるべきです．また，差動インピーダンスを考慮する必要があり，普段の配線よりも気を使う点が多いです．以下の点に気をつけて配線をお願いします．  
- 差動インピーダンスを90Ωに近づける（[JLCPCB公式計算ツール](https://jlcpcb.com/jp/pcb-impedance-calculator)）
- KiCad「配線 ＞ 差動ペアの配線」機能を使用する  

- 同一レイヤー上で配線する（front面とback面を行き来しない）
- できるだけ配線を曲げず，一直線に配線する
- 電源線（5V，3.3Vなど）を近くに置かない
- Type-Cに接続するときに配線幅を変える必要がある場合，ティアドロップ（フィレット的な機能，以下「ティアドロップの使用」参照）を使用して滑らかに幅を変化させる  

- USB配線の裏面に別の配線を置かない（↓ダメな例）  

---

### テストポイント（TP）について
TPは基板を作ったあとに正しく信号が流れているかオシロスコープやテスターを用いて確認するために重要です．一方でノイズの発生源となったり逆にノイズを拾ったりすることも考えられます．その為，できるだけ少ない数配置すべきです．また，USBやGPIOなどの信号線にはできるだけ配置したくありません．どうしても配置する必要がある場合は，以下のように配線上に置くようにし，枝分かれしたところに置くことはやめてください．

---  

### ティアドロップの使用
今まで（25代まで）はパッドと配線の接続やビアとの接続時に特に何も考えずにやってきたと思います．ただ，これから密度の高い基板を作るにあたってノイズの発生を最大限に抑制する必要があり，急激な配線幅の変化をなくすべきです．今まで配線を90°に曲げるのは良くないと言われてきたのも同じ理由からです．そこでティアドロップ機能を使います．この機能は以下の画像の様に徐々に幅を変化させてくれるのでノイズが軽減されるはずです．また，この機能のオブジェクトはゾーンになっているため，機能が適応できない場合はゾーンが非表示になっていないか確認してください．以下がティアドロップの適用手順です．  
1.  編集 ＞ ティアドロップを編集  
  
2.  
3.   

--- 

### ビアについて
ビアには主に2つの目的があります．
- 配線をfrontからbackに移す（逆も然り）
- 層間のコンデンサ形成を防ぐ

例えば2層基板なら1層目と2層目の間の絶縁体を誘電体としたコンデンサにならないようにする．  
  
1つ目の目的でビアを使うのは一般的ですが，2つ目のコンデンサになるのを防ぐ目的でビアを使用しているか確認してください．置く位置はfrontとbackのベタGNDが重なっているところで，角になっている部分や近くにビアがないところです．定期的に配置することでコンデンサ化を防ぐ効果が高まります．  

---
### コンデンサを置く位置について  
コンデンサには電源や信号が不安定になった時にそれを補正してくれる役割があります．そのため，補正したい端子のできるだけ近くに置くことでその効果を十分に活用することができます．配線時にはそのコンデンサが

---
---
## 基板作成のコツ  
素子が多く，複雑な基板になればなるほど基板作成の難易度は上がります．どこに素子を置けば配線が最短になるのか，表と裏を無駄に行き来しないようにできるのか，見た目もきれいな基板になるのか，など考えることが増えていきます．そんな時に役に立つのが

## KiCad design Prototype_3（1月～）/Teseo-LIV3FL(GNSS module)/Teseo-LIV3FL(GNSS module).kicad_pcb

Parts:
C1: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: LED; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder
IC1: TESEO-LIV3FL; TESEOLIV3FL; Manufacturer_Part_Number TESEO-LIV3FL; Mouser Part Number 511-TESEO-LIV3FL
J1: Conn_Coaxial; U.FL_Hirose_U.FL-R-SMT-1_Vertical
J2: Conn_01x05_Pin; PinHeader_1x05_P2.54mm_Vertical
L1: 27nH; L_0402_1005Metric_Pad0.77x0.64mm_HandSolder
R1: 200Ω; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
R2: 10Ω; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder

Connections:
+3V3: C1.1, IC1.6 (VBATT), IC1.7 (VCC_IO), IC1.8 (VCC), J2.4
GND: C1.2, D1.1 (K), IC1.1 (GND), J2.3
GND1: IC1.10 (GND_RF_1), IC1.12 (GND_RF_2), J1.2 (Ext)
unnamed: D1.2 (A), R1.2
unnamed: IC1.4 (1PPS), J2.2, R1.1
unnamed: IC1.11 (RF_IN), J1.1 (In), L1.1
unnamed: IC1.3 (RX), J2.1
unnamed: IC1.2 (TX), J2.5
unnamed: IC1.14 (VCC_RF), R2.2
unnamed: L1.2, R2.1

Board: 2 copper layers, 17.0 x 27.5 mm, 8 parts (0 on the bottom side), 10 nets.

## KiCad design Prototype_2（～12月）/各素子用/ICS/ICS.kicad_pcb

Parts:
J1: Conn_01x04_Socket; PinHeader_1x04_P2.54mm_Vertical
J2: Conn_01x03_Socket; PinHeader_1x03_P2.54mm_Vertical
R1: 2.2k; R_0805_2012Metric
U1: 74AHC1G04W5
U2, U3: 74AUC1G125; 74AHC1G04W5

Connections:
+3V3: J1.4, U2.5 (VCC)
+5V: J2.1, R1.1, U1.5 (Vcc), U3.5 (VCC)
GND: J1.2, U1.3 (GND), U2.3 (GND), U3.3 (GND)
unnamed: J1.1, U3.2
unnamed: J1.3, U2.4
unnamed: J2.2, R1.2, U2.2, U3.4
unnamed: J2.3, U1.2 (A), U2.1
unnamed: U1.4 (Y), U3.1

Notes on the sheet:
TX_OUT
EN_IN
GND
RX_IN
ICS_SIG
ICS Device
3V3
XIAO

Board: 2 copper layers, 10.3 x 10.7 mm, 6 parts (0 on the bottom side), 8 nets.

## KiCad design Prototype_2（～12月）/各素子用/BNO055/BNO055.kicad_pcb

Parts:
C1: 10u; C_0805_2012Metric
C2, C3, C10: 2.2u; C_0603_1608Metric
C4, C5, C6, C7, C8: 100n; C_0402_1005Metric
C9, C11: 15p; C_0603_1608Metric
J2: Conn_01x04_Socket; PinHeader_1x04_P2.54mm_Vertical
R1, R2, R4, R5: 10k; R_0603_1608Metric
TP2, TP3, TP4, TP5: TestPoint; TestPoint_Pad_1.0x1.0mm
U1: LP5907MFX-2.8; SOT-23-5_HandSoldering
U2: BNO055; LGA-28_5.2x3.8mm_P0.5mm
U3: MICROPAK_FXMA2102L8X
Y1: Crystal; Crystal_SMD_3215-2Pin_3.2x1.5mm

Connections:
+2V8: C3.1, C5.1, C6.1, C7.1, C8.1, R1.1, R2.1, R5.1, U1.5 (OUT), U2.3 (VDD), U2.28 (VDDIO), U3.8 (VCCB)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, J2.2, R4.2, U1.2 (GND), U2.2 (GND), U2.5 (PS1), U2.6 (PS0), U2.18 (COM2), U2.25 (GNDIO), U3.4 (GND)
unnamed: J2.3, U3.2 (A0)
unnamed: J2.4, U3.3 (A1)
unnamed: TP3.1, U2.10 (BL_IND)
unnamed: C10.1, U2.9 (CAP)
unnamed: R1.2, U2.20 (COM0), U3.7 (B0)
unnamed: R2.2, U2.19 (COM1), U3.6 (B1)
unnamed: R4.1, U2.17 (COM3)
unnamed: TP4.1, U2.7 (PIN7)
unnamed: TP5.1, U2.8 (PIN8)
unnamed: C9.1, U2.27 (XIN32), Y1.1
unnamed: C11.1, U2.26 (XOUT32), Y1.2
unnamed: R5.2, TP2.1, U2.4 (~BOOT_LOAD_PIN)
VCC: C1.1, C2.1, C4.1, J2.1, U1.1 (IN), U1.3 (EN), U3.1 (VCCA), U3.5 (OE)

Board: 2 copper layers, 17.2 x 17.1 mm, 24 parts (0 on the bottom side), 15 nets.

File Prototype_2（～12月）/各素子用/BNO055/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
C1,0805,1,10u,
"C10, C2, C3",0603,3,2.2u,
"C11, C9",0603,2,15p,
"C4, C5, C6, C7, C8",0402,5,100n,
J2,PinHeader_1x04_P2.54mm_Vertical,1,Conn_01x04_Socket,
"R1, R2, R4, R5",0603,4,10k,
"TP2, TP3, TP4, TP5",TestPoint_Pad_1.0x1.0mm,4,TestPoint,
U1,SOT-23-5_HandSoldering,1,LP5907MFX-2.8,
U2,LGA-28_5.2x3.8mm_P0.5mm,1,BNO055,
U3,MICROPAK_FXMA2102L8X,1,~,
Y1,Crystal_SMD_3215-2Pin_3.2x1.5mm,1,Crystal,

## KiCad design Prototype_2（～12月）/ブレッドボード_1/ブレッドボード_1.kicad_pcb

Parts:
J1: SDP31-500; PinSocket_1x04_P2.54mm_Vertical
J2: AS5600_1; PinSocket_1x06_P2.54mm_Vertical
J3: SD_1; PinSocket_1x06_P2.54mm_Vertical
J4: AS5600_0; PinSocket_1x06_P2.54mm_Vertical
J5: Conn_01x12_Socket; PinHeader_2x06_P2.54mm_Horizontal

Connections:
/3V3_AS0: J1.2, J2.1, J2.2, J3.5, J4.1, J4.2, J5.11
/CLK_SD1: J3.4, J5.5
/CS_SD1: J3.1, J5.12
/DC_GND: J1.4, J2.3, J3.3, J4.3, J5.4
/MISO_SD1: J3.6, J5.6
/MOSI_SD1: J3.2, J5.7
/SCL_AS0: J4.4, J5.9
/SCL_AS1: J1.1, J2.4, J5.1
/SDA_AS0: J4.5, J5.10
/SDA_AS1: J1.3, J2.5, J5.3

Board: 2 copper layers, 52.2 x 23.5 mm, 5 parts (0 on the bottom side), 10 nets.

File Prototype_2（～12月）/ブレッドボード_1/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
J1,PinSocket_1x04_P2.54mm_Vertical,1,SDP31-500,
J2,PinSocket_1x06_P2.54mm_Vertical,1,AS5600_1,
J3,PinSocket_1x06_P2.54mm_Vertical,1,SD_1,
J4,PinSocket_1x06_P2.54mm_Vertical,1,AS5600_0,
J5,PinHeader_2x06_P2.54mm_Horizontal,1,Conn_01x12_Socket,

## KiCad design Prototype_2（～12月）/各素子用/TORICAberry Pi Bico(3rd Edition)/TORICAberry Pi Bico(3rd Edition).kicad_pcb

Parts:
C1, C2, C4, C6, C7, C8, C9, C10, C11, C12, C13: 100n; C_0201_0603Metric
C3, C5: 1u; C_0402_1005Metric
C14, C15: 15p; C_0201_0603Metric
C16, C17, C18: 10u; C_0402_1005Metric
D1, D2, D3, D4, D5, D6: LED; LED_0201_0603Metric
D7: D_Schottky; Schottly new SBR2U30P1
J1: USB_C_Receptacle; Type-C
J2: Conn_01x08_Socket; PinHeader_1x08_P2.54mm_Vertical
J3: Conn_01x12_Socket; PinHeader_1x12_P2.54mm_Vertical
R1, R2: 27; R_0402_1005Metric
R3, R4: 1k; R_0402_1005Metric
R5, R6, R7, R8, R9, R10: 470; R_0402_1005Metric
R11, R12: 5.1k; R_0402_1005Metric
SW1, SW2: SW_Push; Tactil Switch
U1: RP2040; QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm
U2: Winbond_USON-8-1EP_3x2mm_P0.5mm_EP0.2x1.6mm
U3: NCP1117-3.3_TO252; 3pin regulator
Y1: Crystal_GND24; 12MHz

Connections:
+1V1: C1.2, C2.2, C3.2, U1.23 (DVDD), U1.45 (VREG_VOUT), U1.50 (DVDD)
+3V3: C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.1, C11.1, C12.2, C13.1, C16.1, C18.1, J2.2, U1.1 (IOVDD), U1.10 (IOVDD), U1.22 (IOVDD), U1.33 (IOVDD), U1.42 (IOVDD), U1.43 (ADC_AVDD), U1.44 (VREG_IN), U1.48 (USB_VDD), U1.49 (IOVDD), U2.8 (VCC), U3.2 (VO)
/GPIO0: J3.2, U1.2 (GPIO0)
/GPIO1: J3.3, U1.3 (GPIO1)
/GPIO2: J3.4, U1.4 (GPIO2)
/GPIO3: J3.5, U1.5 (GPIO3)
/GPIO4: J3.6, U1.6 (GPIO4)
/GPIO5: J3.7, U1.7 (GPIO5)
/GPIO8: R6.1, U1.11 (GPIO8)
/GPIO9: R7.1, U1.12 (GPIO9)
/GPIO10: R5.1, U1.13 (GPIO10)
/GPIO11: J3.8, U1.14 (GPIO11)
/GPIO12: J3.9, U1.15 (GPIO12)
/GPIO13: J3.10, U1.16 (GPIO13)
/GPIO14: J3.11, U1.17 (GPIO14)
/GPIO15: J3.12, U1.18 (GPIO15)
/GPIO16: J2.8, U1.27 (GPIO16)
/GPIO17: J2.7, U1.28 (GPIO17)
/GPIO20: J2.6, U1.31 (GPIO20)
/GPIO21: J2.5, U1.32 (GPIO21)
/GPIO22: R8.1, U1.34 (GPIO22)
/GPIO23: R9.1, U1.35 (GPIO23)
/GPIO24: R10.1, U1.36 (GPIO24)
/GPIO26_ADC0: J2.4, U1.38 (GPIO26_ADC0)
/GPIO27_ADC1: J2.3, U1.39 (GPIO27_ADC1)
/QSPI_SCLK: U1.52 (QSPI_SCLK), U2.6 (CLK)
/QSPI_SD0: U1.53 (QSPI_SD0), U2.5 (DI_IOD)
/QSPI_SD1: U1.55 (QSPI_SD1), U2.2 (DO_IO1)
/QSPI_SD2: U1.54 (QSPI_SD2), U2.3 (WP_IO2)
/QSPI_SD3: U1.51 (QSPI_SD3), U2.7 (HOLD_IO3)
/QSPI_SS: R3.2, U1.56 (QSPI_SS), U2.1 (CS)
/RUN: SW1.1, U1.26 (RUN)
/USB_D+: J1.A6 (D+), J1.B6 (D+), R1.1
/USB_D-: J1.A7 (D-), J1.B7 (D-), R2.1
/VBUS: D7.2 (A), J1.A4 (VBUS)
/VSYS: C17.1, D7.1 (K), J2.1, U3.3 (VI)
/XIN: C14.2, U1.20 (XIN), Y1.1
/XOUT: R4.2, U1.21 (XOUT)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.2, C11.2, C12.1, C13.2, C14.1, C15.1, C16.2, C17.2, C18.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), J1.A1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J3.1, R11.2, R12.2, SW1.2, SW2.1, U1.19 (TESTEN), U1.57 (GND), U2.4 (GND), U3.1 (GND), Y1.2, Y1.4
unnamed: C15.2, R4.1, Y1.3
unnamed: D1.2 (A), R5.2
unnamed: D2.2 (A), R6.2
unnamed: D3.2 (A), R7.2
unnamed: D4.2 (A), R8.2
unnamed: D5.2 (A), R9.2
unnamed: D6.2 (A), R10.2
unnamed: J1.A5 (CC1), R11.1
unnamed: J1.B5 (CC2), R12.1
unnamed: R3.1, SW2.2
unnamed: R2.2, U1.46 (USB_DM)
unnamed: R1.2, U1.47 (USB_DP)

Notes on the sheet:
44の近くに配置
Reset
Flash Memory
RP2040
Power Unit
Pin Header
45の近くに配置
BOOTSEL
Crystal Oscillator
LED

Board: 2 copper layers, 24.2 x 33.9 mm, 46 parts (3 on the bottom side), 51 nets.

File Prototype_2（～12月）/各素子用/TORICAberry Pi Bico(3rd Edition)/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C10, C11, C12, C13, C2, C4, C6, C7, C8, C9",0201,11,100n,
"C14, C15",0201,2,15p,
"C16, C17, C18",0402,3,10u,
"C3, C5",0402,2,1u,
"D1, D2, D3, D4, D5, D6",0201,6,LED,
D7,Schottly new SBR2U30P1,1,D_Schottky,
J1,Type-C,1,USB_C_Receptacle,
J2,PinHeader_1x08_P2.54mm_Vertical,1,Conn_01x08_Socket,
J3,PinHeader_1x12_P2.54mm_Vertical,1,Conn_01x12_Socket,
"R1, R2",0402,2,27,
"R10, R5, R6, R7, R8, R9",0402,6,470,
"R11, R12",0402,2,5.1k,
"R3, R4",0402,2,1k,
"SW1, SW2",Tactil Switch,2,SW_Push,
U1,QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm,1,RP2040,
U2,Winbond_USON-8-1EP_3x2mm_P0.5mm_EP0.2x1.6mm,1,~,
U3,3pin regulator,1,NCP1117-3.3_TO252,
Y1,12MHz,1,Crystal_GND24,

## KiCad design Prototype_2（～12月）/ブレッドボード_3/ブレッドボード_3.kicad_pcb

Parts:
J1: Conn_01x12_Socket; PinHeader_2x06_P2.54mm_Horizontal
J2: BNO055; PinSocket_1x04_P2.54mm_Vertical
J3: SD_0; PinSocket_1x06_P2.54mm_Vertical
J4: GPS; PinSocket_1x04_P2.54mm_Vertical
J5: Conn_01x12_Socket; PinHeader_1x12_P2.54mm_Vertical
J6: ICS; PinSocket_1x04_P2.54mm_Vertical
J7: Conn_01x08_Socket; PinSocket_1x08_P2.54mm_Vertical
J8: ICS; PinSocket_1x03_P2.54mm_Vertical
J9: SPK; PA_Connector_Post_2Pin
J10: XIAO_Rudder; CONN_B05B-PASK_JST
J11: XIAO_Under; PA_Connector_Pos_4Pin
J12: SIG_ICS; CONN_B02B-PASK-1_JST

Connections:
/3V3_BNO: J1.2, J2.1, J3.5, J4.1, J6.4, J7.2
/5V_DC_Bico: J1.5, J7.1
/5V_DC_ICS: J1.4, J8.1
/5V_DC_Rudder: J1.3, J10.5
/5V_DC_Under: J1.1, J11.4
/CLK_SD0: J3.1, J5.11
/CS_SD0: J3.2, J5.10
/DC_GND: J1.6, J2.2, J3.6, J4.2, J5.1, J6.2, J9.2, J10.1, J11.1
/EN_ICS: J8.3, J10.2
/MISO_SD0: J3.3, J5.9
/MOSI_SD0: J3.4, J5.8
/RX_ESP: J1.11, J7.7
/RX_GPS: J4.3, J5.4
/RX_ICS: J6.1, J10.3
/RX_Under: J5.7, J11.2
/SCL_AS0: J1.7, J2.3, J7.4
/SCL_BNO: J1.8, J2.4, J7.3
/SCL_SDP_AS1: J1.10, J7.6
/SDA_SDP_AS1: J1.9, J7.5
/SIG_ICS: J5.3, J8.2, J12.1, J12.2
/SPK: J5.12, J9.1
/TX_ESP: J1.12, J7.8
/TX_GPS: J4.4, J5.5
/TX_ICS: J6.3, J10.4
/TX_Under: J5.6, J11.3

Notes on the sheet:
GP0
3V3
TX_OUT
EN_IN
GND
VSYS
RX_IN
Bico
ICS_SIG

Board: 2 copper layers, 100.0 x 23.5 mm, 12 parts (4 on the bottom side), 25 nets.

File Prototype_2（～12月）/ブレッドボード_3/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
J1,PinHeader_2x06_P2.54mm_Horizontal,1,Conn_01x12_Socket,
J10,CONN_B05B-PASK_JST,1,XIAO_Rudder,
J11,PA_Connector_Pos_4Pin,1,XIAO_Under,
J12,CONN_B02B-PASK-1_JST,1,SIG_ICS,
J2,PinSocket_1x04_P2.54mm_Vertical,1,BNO055,
J3,PinSocket_1x06_P2.54mm_Vertical,1,SD_0,
J4,PinSocket_1x04_P2.54mm_Vertical,1,GPS,
J5,PinHeader_1x12_P2.54mm_Vertical,1,Conn_01x12_Socket,
J6,PinSocket_1x04_P2.54mm_Vertical,1,ICS,
J7,PinSocket_1x08_P2.54mm_Vertical,1,Conn_01x08_Socket,
J8,PinSocket_1x03_P2.54mm_Vertical,1,ICS,
J9,PA_Connector_Post_2Pin,1,SPK,

## KiCad design Prototype_2（～12月）/ブレッドボード_2/ブレッドボード_2.kicad_pcb

Parts:
J1, J6: Conn_01x12_Socket; PinSocket_2x06_P2.54mm_Vertical
J2: BMP390; PinSocket_1x04_P2.54mm_Vertical
J3: LiPo; PA_Connector_Post_2Pin
U1, U2, U3, U4, U5: MCP1703Ax-120xxDB; Converter_DCDC_RECOM_R-78E-0.5_THT
U6: XIAO-ESP32-S3-SMD; Seeeduino XIAO-MOUDLE14P-2.54-21X17.8MM

Connections:
/3V3_BMP: J2.1, J6.11
/3V3_ESP: J1.11, U6.12 (3V3)
/5V_DC_Bico: J6.8, U2.3 (VO)
/5V_DC_ESP: U3.3 (VO), U6.14 (5V)
/5V_DC_ICS: J6.9, U1.3 (VO)
/5V_DC_Rudder: J6.10, U4.3 (VO)
/5V_DC_Under: J6.12, U5.3 (VO)
/CLK_SD1: J1.5, U6.9 (GPIO7_A8_D8_SCK)
/CS_SD1: J1.12, U6.1 (GPIO1_A0_D0)
/DC_GND: J1.4, J2.2, J3.2, J6.7, U1.2 (GND), U2.2 (GND), U3.2 (GND), U4.2 (GND), U5.2 (GND), U6.13 (GND)
/LiPo: J3.1, U1.1 (VI), U2.1 (VI), U3.1 (VI), U4.1 (VI), U5.1 (VI)
/MISO_SD1: J1.6, U6.10 (GPIO8_A9_D9_MISO)
/MOSI_SD1: J1.7, U6.11 (GPIO9_A10_D10_MOSI)
/RX_ESP: J6.2, U6.8 (GPIO44_D7_RX)
/SCK_BMP: J1.9, J2.3, J6.5
/SCL_SDP_AS1: J1.1, J6.3
/SDA_AS0: J1.10, J2.4, J6.6
/SDA_SDP_AS1: J1.3, J6.4
/TX_ESP: J6.1, U6.7 (GPIO43_A6_D6_TX)

Notes on the sheet:
Under
ICS
ESP32
Rudder
Bico

Board: 2 copper layers, 100.0 x 23.5 mm, 10 parts (1 on the bottom side), 19 nets.

File Prototype_2（～12月）/ブレッドボード_2/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"J1, J6",PinSocket_2x06_P2.54mm_Vertical,2,Conn_01x12_Socket,
J2,PinSocket_1x04_P2.54mm_Vertical,1,BMP390,
J3,PA_Connector_Post_2Pin,1,LiPo,
"U1, U2, U3, U4, U5",Converter_DCDC_RECOM_R-78E-0.5_THT,5,MCP1703Ax-120xxDB,
U6,Seeeduino XIAO-MOUDLE14P-2.54-21X17.8MM,1,XIAO-ESP32-S3-SMD,
